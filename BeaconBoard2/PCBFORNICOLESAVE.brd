# Repository Labbaker/SeniorDesign

File README.md:

# SeniorDesign
Checklist of things to do:

Main Station Software:
main page: beacon map, view emergency alerts, sidebar w/ new alerts (all pages have back to main menu option)
Map view of beacons - map of the tucson area with icons for each beacon, (gps coords on mouseover? ping on mouseover?) displays if alert triggered or repair needed.
Emergency alerts page: new displayed, resolved on different page
-resolved page: data abt alert
when viewing new alert, text box for message + ack
yes/no for resolving alert

backend stuff: 
Xbee connection - receive GPS data from beacons
XBee connection - get alerts from beacons after the beacons get them from the app
XBee - send ack + message to alert device
Interface with MySQL database?!?! PHP database!?!?!?
pings beacons every hour

Mobile Application:
Main page: buttons for emergencies options, map, "about app" and (about me") - each of these pages has a link back to the main page
About app: just text
map view: pre downloaded map of tucson that will get the user's GPS location and display their location on the map, 
or text that says "outside bounds" if their location ins't on the map. If the phones gps isn't working, get the gpd coords of the nearet
beacon and draw a circle of 20m around that point that says "you're within this circle"
Emergency options: 3 buttons for 3 levels of emergency, yes/no confirm after. 
- these have 4 states: no yes/no (fine), yes, no, no yes/no (not fine) (if rest is finished, add optional text box)
ack screen: "sending" (after hitting button) "sending..." (ack from beacon). (send) ack from main station (text), reset button 
(display note from main station)
About me: (optional) ICE info (medical conditions, contact info)

Beacon Software:
GPS connection: get the beacon's gps, save it. get new coords once every 24 hours, gps should sleep
bluetooth/mobile app: 
(according to adafruit tutorial) broadcasts a char string that mobile app bluetooth looks for
send GPS coords if mobile app requests it for map. 
transmit all the stuff related to alerts/ack'ing them
responds to main station ping every hour

Connections:
Mobile app -> Beacon
Initial Bluetooth connection
Emergency commands
GPS request

Beacon -> Mobile App
Initial Bluetooth connection
Emergency command ack
GPS

Beacon -> Beacon
Mesh Network
Passing GPS
emergency alerts

Beacon -> main station
mesh network connection
ack w/ time and GPS
emergency alerts

main station -> beacon
mesh network
ping request
emergency alert ack w/ note

## EAGLE design BeaconBoard2/PCBFORNICOLESAVE.brd

Parts:
C1, C2, C3, C4, C5, C6, C16: 100n; 0603
C7, C17: 10u; 1206
D7, D8: BAT54; SOD323
D9, D10, D11, D12, D13, D14, D15, D16: LED1206; 1206
PC0-8: PINHD-1X82MM; 1X08_2MM
PK0-3: PINHD-1X42MM; 1X04_2MM
R11: 10k; 0603
R12, R16, R17, R18, R19, R20, R21, R22, R23: 1k; 0603
RESET: 1P1T-NOTH; 6X6MM-TH
U1: ATMega2560; 100QFP
Y1: XRES1206; 1206XRES

Connections:
3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C17.1, D7.2 (C), R11.2, U1.10, U1.31, U1.61, U1.80, U1.100; also elsewhere on the board
ADC_BATT: U1.83; also elsewhere on the board
ADC_SOLAR: U1.82; also elsewhere on the board
AREF: C1.1, U1.98
BT_MODE: U1.14; also elsewhere on the board
BT_RX: U1.13; also elsewhere on the board
BT_TX: U1.12; also elsewhere on the board
DBG_RX: U1.2; also elsewhere on the board
DBG_TX: U1.3; also elsewhere on the board
DEBUG_5V: R12.1; also elsewhere on the board
DEBUG_DTR: D8.2 (C); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C17.2, D9.2 (C), D10.2 (C), D11.2 (C), D12.2 (C), D13.2 (C), D14.2 (C), D15.2 (C), D16.2 (C), RESET.3 (A1), RESET.4 (A1), U1.11, U1.32, U1.62, U1.81, U1.99, Y1.2; also elsewhere on the board
GPS_RX: U1.46; also elsewhere on the board
GPS_TX: U1.45; also elsewhere on the board
MISO: U1.22; also elsewhere on the board
MOSI: U1.21; also elsewhere on the board
unnamed: C16.1, D8.1 (A), R12.2
unnamed: D9.1 (A), R16.2
unnamed: D10.1 (A), R17.2
unnamed: D11.1 (A), R18.2
unnamed: D12.1 (A), R19.2
unnamed: D13.1 (A), R20.2
unnamed: D14.1 (A), R21.2
unnamed: D15.1 (A), R22.2
unnamed: D16.1 (A), R23.2
PA0: R16.1, U1.78
PA1: R17.1, U1.77
PA2: R18.1, U1.76
PA3: R19.1, U1.75
PA4: R20.1, U1.74
PA5: R21.1, U1.73
PA6: R22.1, U1.72
PA7: R23.1, U1.71
PB6: U1.25
PB7: U1.26
PC0: PC0-8.1, U1.53
PC1: PC0-8.2, U1.54
PC2: PC0-8.3, U1.55
PC3: PC0-8.4, U1.56
PC4: PC0-8.5, U1.57
PC5: PC0-8.6, U1.58
PC6: PC0-8.7, U1.59
PC7: PC0-8.8, U1.60
PD0: U1.43
PD1: U1.44
PD4: U1.47
PD5: U1.48
PD6: U1.49
PD7: U1.50
PE2: U1.4
PE3: U1.5
PE4: U1.6
PE5: U1.7
PE6: U1.8
PE7: U1.9
PF0: U1.97
PF1: U1.96
PF2: U1.95
PF3: U1.94
PF4: U1.93
PF5: U1.92
PF6: U1.91
PF7: U1.90
PG0: U1.51
PG1: U1.52
PG2: U1.70
PG3: U1.28
PG4: U1.29
PG5: U1.1
PH3: U1.15
PH4: U1.16
PH5: U1.17
PH6: U1.18
PH7: U1.27
PJ2: U1.65
PJ3: U1.66
PJ4: U1.67
PJ5: U1.68
PJ6: U1.69
PJ7: U1.79
PK0: PK0-3.1, U1.89
PK1: PK0-3.2, U1.88
PK2: PK0-3.3, U1.87
PK3: PK0-3.4, U1.86
PK4: U1.85
PK5: U1.84
PL0: U1.35
PL1: U1.36
PL2: U1.37
PL3: U1.38
PL4: U1.39
PL5: U1.40
PL6: U1.41
PL7: U1.42
RESET: C16.2, D7.1 (A), R11.1, RESET.1, RESET.2 (P1), U1.30; also elsewhere on the board
SCK: U1.20; also elsewhere on the board
SD_CD: U1.24; also elsewhere on the board
SD_PWR: U1.23; also elsewhere on the board
SS: U1.19; also elsewhere on the board
XBEE_RX: U1.63; also elsewhere on the board
XBEE_TX: U1.64; also elsewhere on the board
XTAL1: U1.34, Y1.3
XTAL2: U1.33, Y1.1

Parts:
C8: 1u; 0603
C9: 47p; 0603
D3, D17, D18: LED1206; 1206
R5, R24, R25: 1k; 0603
XBEE: XBEE

Connections:
3V3: C8.1, C9.1, D17.1 (A), D18.1 (A), XBEE.1 (VCC); also elsewhere on the board
ASSO: R5.1, XBEE.15 (ASC/AD5/DIO5)
GND: C8.2, C9.2, D3.2 (C), XBEE.10 (GND); also elsewhere on the board
unnamed: D3.1 (A), R5.2
unnamed: D17.2 (C), R24.1
unnamed: D18.2 (C), R25.1
XBEE_RX: R25.2, XBEE.3 (DIN); also elsewhere on the board
XBEE_TX: R24.2, XBEE.2 (DOUT); also elsewhere on the board

Parts:
C10: 100n; 0603
D4, D20, D24: LED1206; 1206
GPS: GPS CHIP; FGPMMOPA6H
R6, R27, R31: 1k; 0603

Connections:
3D-FIX: GPS.P$5 (3D-FIX), R6.1
3V3: C10.1, D20.1 (A), D24.1 (A), GPS.P$1 (VCC); also elsewhere on the board
GND: C10.2, D4.2 (C), GPS.P$3 (GND), GPS.P$8 (GND), GPS.P$12 (GND), GPS.P$19 (GND); also elsewhere on the board
GPS_RX: GPS.P$10 (RX), R31.2; also elsewhere on the board
GPS_TX: GPS.P$9 (TX), R27.2; also elsewhere on the board
unnamed: D4.1 (A), R6.2
unnamed: D20.2 (C), R27.1
unnamed: D24.2 (C), R31.1

Parts:
BT: ADAFRUIT_BLUETOOTH_LE_UART_FRIEND
D19, D21: LED1206; 1206
DFU: PINHD-1X2""; 1X02
R26, R28: 1k; 0603

Connections:
3V3: BT.VIN, R26.1, R28.1; also elsewhere on the board
BT_MODE: BT.MOD; also elsewhere on the board
BT_RX: BT.RXI, D19.2 (C); also elsewhere on the board
BT_TX: BT.TXO, D21.2 (C); also elsewhere on the board
DFU: BT.DFU, DFU.1
GND: BT.CTS, BT.GND, DFU.2; also elsewhere on the board
unnamed: D21.1 (A), R28.2
unnamed: D19.1 (A), R26.2

Parts:
D1, D2: LED1206; 1206
Q3: FDN340P; SSOT-3
R2, R4: 1k; 0603
SD: MICROSDFRONT; USD,FRONT

Connections:
3V3: Q3.3 (D), R4.1; also elsewhere on the board
GND: R2.1, SD.1 (GND), SD.6 (GND), SD.8 (GND), SD.S0 (GND), SD.S1 (GND), SD.S2 (GND), SD.S3 (GND); also elsewhere on the board
MISO: SD.7 (DO); also elsewhere on the board
MOSI: SD.3 (DI); also elsewhere on the board
unnamed: D1.2 (C), R2.2
unnamed: D2.1 (A), R4.2
SCK: D2.2 (C), SD.5 (SCK); also elsewhere on the board
SD_3V3: D1.1 (A), Q3.2 (S), SD.4 (VCC)
SD_CD: SD.SW (CD); also elsewhere on the board
SD_PWR: Q3.1 (G); also elsewhere on the board
SS: SD.2 (CS); also elsewhere on the board

Parts:
C18, C27: 1n; 0603
C19, C20, C21, C26: 100u; 1206
C22, C25: 10u; 1206
C23, C24: 100n; 0603
D5: SCHOTTKYDO214AC; DO214AC
L2: SRN5040TA-330MCT-ND; 2020
Q2: NFETWDFN-6; WDFN-6
R1, R7, R13, R14, R15: 10k; 0603

Connections:
ADC_BATT: C27.1, R14.2, R15.1; also elsewhere on the board
ADC_SOLAR: C18.1, R1.2, R13.1; also elsewhere on the board
BATT+: C24.1, C25.1, C26.1, D5.2 (C), R14.1; also elsewhere on the board
BATT-: C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, Q2.4 (S), Q2.S, R7.2, R13.2; also elsewhere on the board
CHG_GATE: Q2.3 (G), R7.1
GND: C27.2, R15.2; also elsewhere on the board
unnamed: D5.1 (A), L2.2, Q2.1 (D), Q2.2 (D), Q2.5 (D), Q2.6 (D), Q2.PAD (D)
SOLAR+: C19.1, C20.1, C21.1, C22.1, C23.1, L2.1, R1.1; also elsewhere on the board

Parts:
B2: 5X1BUCK-BOOST; UNBRANDED_BUCK-BOOST
BATT-_GND: JUMPERHC_30V; JUMPER_HC_30V
C11, C14: 10u; 1206
C12, C13: 100n; 0603
C15: 100u; 1206
EN_H: JUMPER30V; JUMPER_30V
EN_L: JUMPER30V; JUMPER_30V
L1: 1uH; 1008
U2: 3X3BGA0.4MM; 3X3X0.4BGA

Connections:
3V3: B2.OUT+, C13.1, C14.1, C15.1, U2.C2, U2.C3; also elsewhere on the board
BATT+: B2.IN+, C11.1, C12.1, EN_H.1, U2.A2, U2.B2; also elsewhere on the board
BATT-: B2.IN-, BATT-_GND.1, EN_L.2; also elsewhere on the board
EN: B2.EN, EN_H.2, EN_L.1
GND: B2.OUT-, BATT-_GND.2, C11.2, C12.2, C13.2, C14.2, C15.2, U2.A3, U2.B1, U2.B3; also elsewhere on the board
LX1: L1.1, U2.A1
LX2: L1.2, U2.C1

Parts:
3V3: PINHD-1X4RH; 1X04
BATT: PINHD-1X490RH; 1X04/90
D6: DIODEDO214AC; DO214AC
D22, D23: LED1206; 1206
JP1: PINHD-2X3ISP; 2X03_ISP
R8: 50; 0603
R9: 1.6k; 0603
R10: 3k; 0603
R29, R30: 1k; 0603
SOL1, SOL2: PINHD-1X2/90; 1X02/90
UART: PINHD-1X590RH; 1X05/90

Connections:
3V3: 3V3.1, 3V3.2, R29.1, R30.1; also elsewhere on the board
BATT+: BATT.1, BATT.2, D6.2 (C); also elsewhere on the board
BATT-: BATT.3, BATT.4, SOL1.1, SOL2.2; also elsewhere on the board
DBG_RX: R9.2, R10.2; also elsewhere on the board
DBG_TX: D23.2 (C), R8.2; also elsewhere on the board
DEBUG_5V: D6.1 (A), JP1.5V (2), UART.1; also elsewhere on the board
DEBUG_DTR: UART.5; also elsewhere on the board
DEBUG_RX: D22.2 (C), R9.1, UART.3
DEBUG_TX: R8.1, UART.4
GND: 3V3.3, 3V3.4, JP1.GND (6), R10.1, UART.2; also elsewhere on the board
MISO: JP1.MISO (1); also elsewhere on the board
MOSI: JP1.MOSI (4); also elsewhere on the board
unnamed: D23.1 (A), R30.2
unnamed: D22.1 (A), R29.2
RESET: JP1.RESET (5); also elsewhere on the board
SCK: JP1.SCK (3); also elsewhere on the board
SOLAR+: SOL1.2, SOL2.1; also elsewhere on the board

Board: 2 copper layers, 101.6 x 101.6 mm, 106 parts (0 on the bottom side), 80 nets.

## EAGLE design BeaconBoard/beacon1.brd

Parts:
3V3_ON_LED, 5V_ON_LED, 5V_ON_LED1: GREEN; LED-1206
3V3_REV_LED, 5V_REV_LED, 5V_REV_LED1: RED; LED-1206
ATMEGA2560: ATMEGA2560-16AU; TQFP100
BATT1, BATT2: Battery; 1X02_OVAL
C4, C5: CC1206; C1206
C6, C7, C9, C10: 100n; C1206K
C11: 22p; C1206K
C22, C23: 100m; C1206K
D4: CD1206-S01575; MINIMELF
FTDI1: PINHD-1X6CB; 1X06-CLEANBIG
IC7: LMV358IDGKR; MSOP08
ICSP: 3x2M; 2X03
JP1: HEADER-1X970MIL; 1X09_ROUND_70
JP3: PINHD-1X8BIG; 1X08-BIG
JP4, JP5: HEADER-1X770MIL; 1X07_ROUND_70
JP6: HEADER-1X876MIL; 1X08_ROUND_76
JP8: PWR_IN_0.1; 1X02_OVAL
JP10: LOAD_0.1; 1X02_OVAL
JP11: BATT_IN_0.1; 1X02_OVAL
L: YELLOW; LED-1206
LED2: LED1206; CHIPLED_1206
PWRIN_ON_LED: GREEN; LED-1206
PWRIN_REV_LED: RED; LED-1206
R1: 10; R0805
R4: 1K; 0805-NO
R5: 1M; R1206
R10: 1k; M1206
R11, R12, R13: 10k; M1206
R36, R37, R38, R39, R40, R41, R54: R-US_M1206; M1206
RESET: TS42031-160R-TR-7260; TS42
SOLAR: Solar; 1X02_OVAL
U1: M95M02-DWMN3TP/K; SOIC127P600X175-8N
U$1: XBEE
U$31: DC877A
USB_POWER_ON_LED: GREEN; LED-1206
Y1: CSTCE16M0V53-R0 16MHZ; RESONATOR

Connections:
1PPS: JP1.1
3.3V: C23.2, JP1.9, JP3.2, JP5.5, U1.8 (VCC)
3V3: 3V3_ON_LED.A, C4.1, C5.1, R36.1, U$1.1 (VCC)
5-GND: RESET.5 (5-GND)
5.0V: 5V_REV_LED1.A, FTDI1.3, JP1.2, JP3.1, JP4.7, JP5.7, JP6.4, JP8.2
5V: 5V_ON_LED.A, ATMEGA2560.10 (VCC), ATMEGA2560.31 (VCC1), ATMEGA2560.61 (VCC2), ATMEGA2560.80 (VCC3), ATMEGA2560.100 (AVCC), C7.1, C9.1, C10.1, D4.C, ICSP.2, R11.1, R12.1, R13.1, R37.1
90348: 3V3_REV_LED.A, 5V_REV_LED.A, ATMEGA2560.11 (GND), ATMEGA2560.32 (GND1), ATMEGA2560.62 (GND2), ATMEGA2560.81 (GND3), ATMEGA2560.99 (AGND), C6.2, C7.2, C9.2, C10.2, C11.2, L.C, PWRIN_REV_LED.A, R38.1, R39.1, R40.1, R41.1, RESET.1, RESET.2, U$31.2 (GND), Y1.2
+5V2: BATT1.2, BATT2.2, JP11.2
ADC0: ATMEGA2560.97 ((ADC0)PF0)
ADC1: ATMEGA2560.96 ((ADC1)PF1)
ADC2: ATMEGA2560.95 ((ADC2)PF2)
ADC3: ATMEGA2560.94 ((ADC3)PF3)
ADC4: ATMEGA2560.93 ((ADC4/TCK)PF4)
ADC5: ATMEGA2560.92 ((ADC5/TMS)PF5)
ADC6: ATMEGA2560.91 ((ADC6/TDO)PF6)
ADC7: ATMEGA2560.90 ((ADC7/TDI)PF7)
ADC8: ATMEGA2560.89 (PK0(ADC8/PCINT16))
ADC9: ATMEGA2560.88 (PK1(ADC9/PCINT17))
ADC10: ATMEGA2560.87 (PK2(ADC10/PCINT18))
ADC11: ATMEGA2560.86 (PK3(ADC11/PCINT19))
ADC12: ATMEGA2560.85 (PK4(ADC12/PCINT20))
ADC13: ATMEGA2560.84 (PK5(ADC13/PCINT21))
ADC14: ATMEGA2560.83 (PK6(ADC14/PCINT22))
ADC15: ATMEGA2560.82 (PK7(ADC15/PCINT23))
ADO: ATMEGA2560.79 (PJ7)
AREF: ATMEGA2560.98 (AREF), C6.1
CAN_CS: ATMEGA2560.37 (PL2(T5))
CAN_INT: ATMEGA2560.67 (PJ4(PCINT13))
CAN_RESET: ATMEGA2560.15 (PH3(OC4A))
CAN_RX0BF: ATMEGA2560.41 (PL6)
CAN_RX1BF: ATMEGA2560.42 (PL7)
CAN_TX0RTS: ATMEGA2560.38 (PL3(OC5A))
CAN_TX1RTS: ATMEGA2560.39 (PL4(OC5B))
CAN_TX2RTS: ATMEGA2560.40 (PL5(OC5C))
CD: JP3.8
DFU_5V: JP6.1
ENABLE: JP1.8
FIX: JP1.6
GND: C4.2, C5.2, FTDI1.1, ICSP.6, JP1.3, JP3.3, JP4.3, JP4.6, JP5.6, JP6.2, JP8.1, JP10.1, JP11.1, LED2.C, SOLAR.1, U1.4 (VSS), U$1.10 (GND)
GND2: BATT1.1
GND3: BATT2.1
IMU_CS_HI: ATMEGA2560.35 (PL0(ICP4))
IMU_INT_HI: ATMEGA2560.68 (PJ5(PCINT14))
L13: IC7.1 (OUT), IC7.2 (-IN), R10.2
LED0: ATMEGA2560.53 ((A8)PC0)
LED1: ATMEGA2560.54 ((A9)PC1)
LED2: ATMEGA2560.55 ((A10)PC2)
LED3: ATMEGA2560.56 ((A11)PC3)
LED4: ATMEGA2560.57 ((A12)PC4)
LED5: ATMEGA2560.58 ((A13)PC5)
LED6: ATMEGA2560.59 ((A14)PC6)
LED7: ATMEGA2560.60 ((A15)PC7)
LED8: ATMEGA2560.78 ((AD0)PA0)
LED9: ATMEGA2560.77 ((AD1)PA1)
LED10: ATMEGA2560.76 ((AD2)PA2)
LED11: ATMEGA2560.75 ((AD3)PA3)
LED12: ATMEGA2560.74 ((AD4)PA4)
LED13: ATMEGA2560.73 ((AD5)PA5)
LED14: ATMEGA2560.72 ((AD6)PA6)
LED15: ATMEGA2560.71 ((AD7)PA7)
MISO: ATMEGA2560.22 ((MISO/PCINT3)PB3), ICSP.1, JP3.5, U1.2 (Q)
MODE_5V: JP6.8
MOSI: ATMEGA2560.21 ((MOSI/PCINT2)PB2), ICSP.4, JP3.6, U1.5 (D)
unnamed: 5V_ON_LED1.A, JP10.2
unnamed: FTDI1.6, R1.1
unnamed: JP4.1, SOLAR.2
unnamed: LED2.A, R4.2
unnamed: L.A, R10.1
unnamed: PWRIN_ON_LED.C, R40.2
unnamed: R41.2, USB_POWER_ON_LED.C
unnamed: PWRIN_REV_LED.C, R54.2
unnamed: C23.1, U$31.3 (VOUT)
unnamed: C22.1, U$31.5 (VIN)
unnamed: 5V_ON_LED1.C, 5V_REV_LED1.C, C22.2
unnamed: 3V3_REV_LED.C, R36.2
unnamed: 5V_ON_LED.C, R38.2
unnamed: R4.1, U$1.15 (ASC/AD5/DIO5)
unnamed: 5V_REV_LED.C, R37.2
unnamed: 3V3_ON_LED.C, R39.2
PB0: ATMEGA2560.19 ((SS/PCINT0)PB0), JP3.7, U1.1 (!S)
PB4: ATMEGA2560.23 ((OC2A/PCINT4)PB4), JP6.3
PB5: ATMEGA2560.24 ((OC1A/PCINT5)PB5), JP6.7
PB6: ATMEGA2560.25 ((OC1B/PCINT6)PB6), FTDI1.2
PB7: ATMEGA2560.26 ((OC0A/OC1C/PCINT7)PB7), IC7.3 (+IN)
PD7: ATMEGA2560.50 ((T0)PD7)
PE3: ATMEGA2560.5 ((OC3A/AIN1)PE3)
PE4: ATMEGA2560.6 ((OC3B/INT4)PE4)
PE5: ATMEGA2560.7 ((OC3C/INT5)PE5)
PE6: ATMEGA2560.8 ((T3/INT6)PE6)
PE7: ATMEGA2560.9 ((CLKO/ICP3/INT7)PE7)
PG: JP4.5
PG0: ATMEGA2560.51 ((WR)PG0)
PG1: ATMEGA2560.52 ((RD)PG1)
PG2: ATMEGA2560.70 ((ALE)PG2)
PG5: ATMEGA2560.1 ((OC0B)PG5)
PH4: ATMEGA2560.16 (PH4(OC4B))
PH5: ATMEGA2560.17 (PH5(OC4C))
PH6: ATMEGA2560.18 (PH6(OC2B))
PS: JP4.4
PWRIN: PWRIN_ON_LED.A, R54.1
RESET: ATMEGA2560.30 (RESET), C11.1, D4.A, ICSP.5, R1.2, R11.2, RESET.3, RESET.4
RI: ATMEGA2560.66 (PJ3(PCINT12))
RXD0: FTDI1.4
RXD1: ATMEGA2560.45 ((RXD1/INT2)PD2)
RXD2: ATMEGA2560.12 (PH0(RXD2)), JP6.6
RXD3: ATMEGA2560.63 (PJ0(RXD3/PCINT9)), JP1.5
RX_1: U$1.2 (DOUT)
SCK: ATMEGA2560.20 ((SCK/PCINT1)PB1), ICSP.3, JP3.4, U1.6 (C)
SCL: ATMEGA2560.43 ((SCL/INT0)PD0), R13.2
SDA: ATMEGA2560.44 ((SDA/INT1)PD1), R12.2
SD_CARD_DETECT_1: ATMEGA2560.69 (PJ6(PCINT15))
SD_CS_HI: ATMEGA2560.36 (PL1(ICP5))
SLEEP: ATMEGA2560.65 (PJ2(XCK3/PCINT11))
TXD0: FTDI1.5
TXD1: ATMEGA2560.46 ((TXD1/INT3)PD3)
TXD2: ATMEGA2560.13 (PH1(TXD2)), JP6.5
TXD3: ATMEGA2560.64 (PJ1(TXD3/PCINT10)), JP1.4
TX_1: U$1.3 (DIN)
USBVCC: USB_POWER_ON_LED.A
V+: IC7.8 (V+)
V-: IC7.4 (V-)
VBACKUP: JP1.7
XBEE_SIGNAL_1: U$1.6 (PWM0/RSSI)
XTAL1: ATMEGA2560.34 (XTAL1), R5.1, Y1.3
XTAL2: ATMEGA2560.33 (XTAL2), R5.2, Y1.1

Notes on the sheet:
Arduino MEGA 2560
(SCK)
(MISO)
(MOSI)
pwm
Bluetooth chip and relevant power circuitry from schematic
Power circuitry dfrom Arduino reference schematic, may be changed from linear regulators to bucks for efficency
Reset
FTDI Chip for programming
Arduino Mega Reference
Xbee Reference
GPS circuit from Adafruit
Misc circuitry, including ICSP programing header, status leds, I2C pull ups
SD Card and EEPROM

Notices in the files:
parts and their libraries:
SparkFun-LED: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
SparkFun-DigitalIC: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
