# Repository Labbaker/SeniorDesign (continued)

## EAGLE design BeaconBoard/beacon1.brd (continued)

Board: 2 copper layers, 101.6 x 100.0 mm, 55 parts (4 on the bottom side), 43 nets.

## EAGLE design beacon1.brd

Board: 2 copper layers, 111.7 x 105.1 mm, 108 parts (0 on the bottom side), 83 nets, no tracks yet.

Parts:
3V3_ON_LED, 5V_ON_LED: GREEN; LED-1206
3V3_REV_LED, 5V_REV_LED: RED; LED-1206
ATMEGA2560: ATMEGA2560-16AU; TQFP100
B1: CR1220
C1: 0.1uF; 0805-NO
C2, C3, C19, C20: 10uF; 0805-NO
C4, C5: C1206
C6, C7, C8, C9, C10, C12, C14, C15, C16: 100n; C1206K
C11: 22p; C1206K
C13: 1u; C1206K
C17, C18: 1uF; 0805-NO
C21: 10uF; _0805MP
D1: 1N4148; SOD-323
D2: CUS520; SOD-323
D3: M7; SMB
D4: CD1206-S01575; MINIMELF
D5: RED; CHIPLED_0805_NOOUTLINE
D6: GREEN; CHIPLED_0805_NOOUTLINE
D7, D12: MBR120; SOD-123
D8, D9, D10, D11: 1n4148; SOD-323
F1: MF-MSMF050-2 500mA; L1812
FB1: Ferrite; 0805-NO@1
FTDI: FT232RL; SSOP28
FTDI_RESET: TEST-POINT2; PAD.02X.02
IC1: NCP1117ST50T3G; SOT223
IC6: LP2985-33DBVR; SOT23-DBV
IC7: LMV358IDGKR; MSOP08
ICSP: 3x2M; 2X03
JP1: 1X09_ROUND_70
JP2: 1X08_ROUND_76
JP3: 1X08_ROUND_70
L: YELLOW; LED-1206
L1: BLM21; 0805
LED1: RED; CHIPLED_0805
LED2: CHIPLED_1206
PC1, PC2: 47u; PANASONIC_D
PWRIN_ON_LED: GREEN; LED-1206
PWRIN_REV_LED: RED; LED-1206
R1, R4, R14, R15: 1K; 0805-NO
R2, R3: 10K; 0805-NO
R5: 1M; R1206
R6, R7, R11, R12, R13: 10k; M1206
R8, R9, R10: 1k; M1206
R16, R17: 100K; 0805-NO
R18: 2K; 0805-NO
R19, R20: 10K; _0805MP
R36, R37, R38, R39, R40, R41, R54: M1206
RESET: TS42031-160R-TR-7260; TS42
RX: YELLOW; 1206
SW1: EG1319; EG1390
T1: FDN340P; SOT-23
TP1: SWCLK; PAD-1.5X2.0
TP2: SWDIO; PAD-1.5X2.0
TP3: FCTRST; PAD-1.5X2.0
TX: YELLOW; 1206
U1: FGPMMOPA6H
U2, U4: MIC5225-3.3; SOT23-5
U3: BLE_MODULE_RAYTAC_MDBT40
U5: MB85RC256VPF-G-JNERE2; SOIC8_208MIL
U$1: XBEE
U$20: U.FL
USB_1: USB-B_TH; PN61729
USB_POWER_ON_LED: GREEN; LED-1206
VTREF: FCTRST; PAD-1.5X2.0
X1: JST 2PH; JSTPH2
Y1: CSTCE16M0V53-R0 16MHZ; RESONATOR
Y2: 32.768kHz (535-9166-2-ND); CRYSTAL_CYL_2X6MM_SMT
Z1, Z2: CG0603MLC-05E; CT/CN0603

Connections:
1PPS: JP1.1, U1.P$13
3.3V: C1.1, C2.1, C17.1, C18.1, C20.1, FB1.2, JP1.9, R3.1, R16.2, R17.2, SW1.O2, U1.P$1, U3.3, U3.14, U4.5, VTREF.P$1
3V3: 3V3_ON_LED.A, C4.1, C5.1, C13.2, IC6.5, IC7.6, R36.1, U$1.1
5V: 5V_ON_LED.A, ATMEGA2560.10, ATMEGA2560.31, ATMEGA2560.61, ATMEGA2560.80, ATMEGA2560.100, C7.1, C9.1, C10.1, C14.1, C16.2, D4.C, FTDI.4, FTDI.20, IC1.2, IC1.4, IC6.1, IC6.3, IC7.8, ICSP.2, PC2.+, R8.2, R9.2, R11.1, R12.1, R13.1, R37.1, T1.2
90348: 3V3_REV_LED.A, 5V_REV_LED.A, ATMEGA2560.11, ATMEGA2560.32, ATMEGA2560.62, ATMEGA2560.81, ATMEGA2560.99, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.1, C16.1, FTDI.18, FTDI.25, IC1.1, IC6.2, IC7.4, ICSP.6, L.C, L1.1, PC1.-, PC2.-, PWRIN_REV_LED.A, R7.1, R38.1, R39.1, R40.1, R41.1, RESET.1, RESET.2, USB_1.4, Y1.2
A0: JP3.1, U5.1
A1: JP3.2, U5.2
A2: JP3.3, U5.3
AREF: ATMEGA2560.98, C6.1
CMP: C15.2, IC7.5, R6.1, R7.2
CONNECTED_LED: R15.1, U3.39
CTS_3V: D8.A, R16.1, U3.28
CTS_5V: D8.C, JP2.7
D+: FTDI.15, USB_1.3, Z2.2
D-: FTDI.16, USB_1.2, Z1.2
DFU_3V: D11.A, U3.24
DFU_5V: D11.C, JP2.1
ENABLE: JP1.8, R2.1, U2.3
FCTRYRST_3V: TP3.P$1, U3.34
FIX: JP1.6, LED1.A, U1.P$5
GATE_CMD: IC7.7, T1.3
GND: B1.-, C1.2, C2.2, C3.2, C4.2, C5.2, C17.2, C18.2, C19.2, C20.2, C21.2, D5.C, D6.C, JP1.3, JP2.2, JP3.7, LED2.C, R1.1, SW1.S2, U1.P$3, U1.P$8, U1.P$12, U1.P$19, U2.2, U3.1, U3.2, U3.13, U3.16, U3.25, U3.42, U4.2, U5.4, U$1.10, U$20.P$1, U$20.P$2, X1.1
L13: IC7.1, IC7.2, R10.2
MISO: ATMEGA2560.22, ICSP.1
MODE_3V: D10.A, U3.18
MODE_5V: D10.C, JP2.8, R18.1
MODE_LED: R14.1, U3.38
MOSI: ATMEGA2560.21, ICSP.4
unnamed: B1.+$1, B1.+$2, D2.A
unnamed: LED1.C, R1.2
unnamed: FB1.1, U2.5
unnamed: U1.P$11, U$20.P$3
unnamed: LED2.A, R4.2
unnamed: L.A, R10.1
unnamed: FTDI.7, FTDI.21, FTDI.26
unnamed: FTDI.19, FTDI_RESET.P$1
unnamed: PWRIN_ON_LED.C, R40.2
unnamed: R41.2, USB_POWER_ON_LED.C
unnamed: D5.A, R14.2
unnamed: D6.A, R15.2
unnamed: U3.9, Y2.1
unnamed: U3.10, Y2.2
unnamed: R18.2, SW1.P2
unnamed: PWRIN_REV_LED.C, R54.2
unnamed: C19.1, D7.C, D12.C, U4.1, U4.3
unnamed: 3V3_REV_LED.C, R36.2
unnamed: 5V_ON_LED.C, R38.2
unnamed: R9.1, RX.A
unnamed: R8.1, TX.A
unnamed: R4.1, U$1.15
unnamed: 5V_REV_LED.C, R37.2
unnamed: 3V3_ON_LED.C, R39.2
PB7: ATMEGA2560.26, IC7.3
PWRIN: D3.A, PWRIN_ON_LED.A, R54.1
RESET: ATMEGA2560.30, C11.1, D4.A, ICSP.5, R11.2, RESET.3, RESET.4
RI: ATMEGA2560.66, FTDI.6
RTS_O: JP2.3, U3.26
RX: D1.C, JP1.4
RXD0: ATMEGA2560.2, FTDI.1
RXD_3V: D9.A, R17.1, U3.29
RXD_5V: D9.C, JP2.5
RXL: FTDI.22, RX.C
RX_3V: D1.A, R3.2, U1.P$10
SCK: ATMEGA2560.20, ICSP.3
SCL: ATMEGA2560.43, JP3.5, R13.2, R19.1, U5.6
SDA: ATMEGA2560.44, JP3.4, R12.2, R20.1, U5.5
SLEEP: ATMEGA2560.65, FTDI.12
SWCLK: TP1.P$1, U3.36
SWDIO/RST_3V: TP2.P$1, U3.35
TX: JP1.5, U1.P$9
TXD0: ATMEGA2560.3, FTDI.5
TXL: FTDI.23, TX.C
TX_O: JP2.6, U3.27
USBVCC: C12.1, F1.1, T1.1, USB_POWER_ON_LED.A
USHIELD: L1.2, USB_1.P$1, USB_1.P$2, Z1.1, Z2.1
VBACKUP: D2.C, JP1.7, U1.P$4
VBAT: D7.A, X1.2
VCC: C21.1, JP3.8, R19.2, R20.2, U5.8
VIN: C3.1, C8.1, D3.C, D12.A, IC1.3, JP1.2, JP2.4, PC1.+, R2.2, R6.2, U2.1
WP: JP3.6, U5.7
XTAL1: ATMEGA2560.34, R5.1, Y1.3
XTAL2: ATMEGA2560.33, R5.2, Y1.1
XVCC: F1.2, USB_1.1

## Commit log

2018-10-20 added GPS schematic and beginning of beacon schematic
2018-10-20 added atmega 2560 to schematic
2018-10-20 made it pretty with notes
2018-10-20 changed net names to fix errors
2018-10-21 made board, really basic unrouted
2018-10-21 added bluetooth chip and condensed layout somewhat, still not routed
2018-10-22 added flash chip and made text formal/pretty
2018-10-22 unrouted, spaced out baoard
2018-10-22 redid layout, might be better for routing?
2018-10-22 almost routed but not quite
2018-10-23 almost 100% routed, but with a lot of gross vias
2018-10-23 save before leaving for meeting
2018-11-11 changed file structure, different folders for each piece of software
2018-11-11 added readmes so folders show up
2018-11-28 i changed everything and only just comitted now cause im bad
2018-12-08 removed full ftdi chip, reset board
2019-01-14 final board design
2019-01-15 made schematic pretty
2019-01-21 reference gps software from adafruit
2019-01-21 changed to hardware rather than software serial
2019-01-21 changed baud rate on example code to match, GPS works
2019-02-07 Added res folder, incomplete as fuck, started app
2019-02-07 readme
2019-02-10 started mobile app
2019-02-10 removed mobile applications, not sure abt it
2019-02-11 beginnings of web gui
2019-02-11 got rid of web gui
2019-02-14 started main station in python, beacon w/ bluetooth & GPS, currently not working :/
2019-02-22 schematic for no breakouts, added basic board layout
2019-03-03 finished board, changed sd card pwr
2019-03-12 removed GPS pps line
2019-03-12 removed sd_gnd traces
2019-03-12 removed GPS PPS again lol
2019-03-14 removed GPS pps (again)
2019-03-14 finished routing, fixed DRC errors and wire stubs, moved components to make soldering easier
2019-03-14 rerouted sd card slightly to fix mistake
2019-03-15 fixed sd card mosfet
2019-03-29 more bluetooth parsing
2019-04-01 full bluetooth w/ end character parsing, works with adafruit demo app. beginnings of xbee
2019-04-01 xbee stuff? might work, unable to test w/ xbees atm, pin issues
2019-04-01 fixed typos in message.txt
2019-04-01 added starting characters
2019-04-02 fixed to read correct indices of ble buffer
2019-04-05 small changes from meeting, char array to string
2019-04-06 added nicole's final board to the repo
2019-04-06 name change
2019-04-06 deleted timerOne stuff
2019-04-07 changed baud rate to match xbee settings
2019-04-08 changed how dummy variables for gps work
2019-04-08 changed to setting at start
2019-04-08 changed messageformats to include end characters
2019-04-15 added basic messages to messageformat.txt, removed some serial debugging lines
2019-04-16 echo test
2019-04-16 real echo
2019-04-29 new parsing for bluetooth
2019-04-29 bluetooth parsing in 4 sections now
2019-04-29 added comma, parenthesis
2019-04-29 done it works
